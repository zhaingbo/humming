# Keil uVision project humming.uvproj, settings and files
target humming (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: humming +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\usr
  group startup
    ./startup/: STARTUP.A51
  group driver
    ./usr/driver/: eeprom.c mpu6050.c nrf24l01.c usart.c
  group app
    ./usr/app/: imu.c stc15w4kpwm.c
  group usr
    ./usr/: main.c timer.c
