# Keil uVision project remoter_controller.uvproj, settings and files
target rc (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: remoter_controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group startup
    ./usr/startup/: STARTUP.A51
  group drivers
    ./usr/driver/: ad.c led.c nrf24l01.c
  group usr
    ./usr/: main.c
